FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"

SRC_URI += " \
                file://inetd.cfg \
                file://simple.script \
"


