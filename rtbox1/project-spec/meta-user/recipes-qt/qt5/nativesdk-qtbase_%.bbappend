do_generate_qt_environment_file[umask] = "022"
