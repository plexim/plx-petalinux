FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"

SRC_URI += " \
                file://plexim.cfg \
                file://inetd.cfg \
"


